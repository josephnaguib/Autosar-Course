# Keil uVision project Motordriver.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Motordriver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Final Project
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    C:/Users/mnaguib/Desktop/Embedded/firstrepo/Final Project/: dio.c dio_cfg.c port.c startup_rvmdk.S port.h dio.h port_types.h bit_math.h STD_Types.h dio_types.h
    ./: MotorDriver.c main.c MotorDriver.h
